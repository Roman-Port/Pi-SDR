<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pisdr_lib_input</value></param>
<param><key>category</key><value>[RomanPort Pi-SDR]</value></param>
<param><key>description</key><value>Main input for PI-SDR</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fm_freq</value></param>
<param><key>value</key><value>92.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>90</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>108</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>IQ Output</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>92.5*1000000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>rtl=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_2</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1400000</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
